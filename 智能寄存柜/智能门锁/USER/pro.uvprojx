# Keil uVision project pro.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\USER;..\SYSTEM;..\DEVICE_LIB\inc;.\delay;..\HARDWARE\Relay;..\HARDWARE\OLED;..\HARDWARE\BEEP;..\HARDWARE\AS608;..\HARDWARE\USART;..\HARDWARE\Key;..\HARDWARE\TIMER;..\HARDWARE\printf;..\HARDWARE\usart1;..\HARDWARE\LED
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s
  group DEVICE_LIB
    ../DEVICE_LIB/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_iwdg.c stm32f4xx_adc.c
  group HARDWARE
    ../HARDWARE/Relay/: Relay.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/AS608/: AS608.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/Key/: key.c
    ../HARDWARE/printf/: printf.c
    ../HARDWARE/usart1/: usart1.c
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group USER
    ./: main.c stm32f4xx_it.c
    ./delay/: delay.c
